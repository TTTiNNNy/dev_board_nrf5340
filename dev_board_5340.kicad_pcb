# Repository TTTiNNNy/dev_board_nrf5340

## KiCad design dev_board_5340.kicad_pcb

Parts:
AE1: Antenna; Texas_SWRA117D_2.4GHz_Left
AE2: Antenna; U.FL_Hirose_U.FL-R-SMT-1_Vertical
C1: N.C.; C_0805_2012Metric
C2, C3: 10pF; C_0805_2012Metric
C4, C19, C20: C_Small; C_0805_2012Metric
C5, C6, C7, C8, C9, C10, C11, C12, C13, C15, C27, C28: 1uF; C_0805_2012Metric
C14: 5uF; C_0805_2012Metric
C16: 4.7uF; C_0805_2012Metric
C17: 100nF; C_0805_2012Metric
C18: 10uF; C_0805_2012Metric
C21, C22, C23, C24: 100pF; C_0805_2012Metric
C25, C26: 10uF; C_1206_3216Metric
C29: 2.2nF; C_0805_2012Metric
D1: ASMT-YTC2-0AA02; LED_Avago_PLCC6_3x2.8mm
D2, D3, D4, D5, D6, D7: LED; D_0805_2012Metric
F1: Fuse; Fuse_1206_3216Metric
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J3: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J4, J5: Conn_01x23; PinHeader_1x23_P2.54mm_Vertical
L1: 2.2nH; L_1206_3216Metric
L2, L3: 10uH; L_1206_3216Metric
R1, R2, R8, R17, R18, R19: 3k5; R_0805_2012Metric
R3: 3k.5; R_0805_2012Metric
R4, R5: R_Small; R_0805_2012Metric
R6, R15: R_Small; R_1206_3216Metric
R7: 10R; C_0805_2012Metric
R9: 2k0; R_0805_2012Metric
R10, R11: 0R0; R_0402_1005Metric
R12: 2R2; R_1206_3216Metric
R13: 2k; C_0805_2012Metric
R14: 10R; R_1206_3216Metric
R16: 1k5; C_0805_2012Metric
SW1, SW2: SW_MEC_5E; SW_Push_1P1T_NO_CK_KSC6xxJ
U1: nrf5340; Nordic_aQFN94_7x7mm_P0.4mm
U2: USBLC6-2SC6; SOT-23-6
U3: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U4: AZ1117-3.3; SOT-223
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: Crystal_32.678; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
/B_LED: J5.10, U1.AK18 (P0.22)
/D+: R14.1, R16.2
/DCC: C28.2, C29.2, L2.1
/G_LED: J5.11, U1.AL15 (P0.21)
/P0.4: J5.21, U1.V2 (AIN0/P0.04)
/P0.5: J5.20, U1.Y2 (AIN1/P0.05)
/P0.6: J5.19, U1.AB2 (AIN2/P0.06)
/P0.7: J5.18, U1.AD2 (AIN3/P0.07)
/P0.8: J5.17, U1.AH2 (TRACEDATA[3]/P0.08)
/P0.9: J5.16, U1.AJ1 (TRACEDATA[2]/P0.09)
/P0.10: J5.15, U1.AK2 (TRACEDATA[1]/P0.10)
/P0.11: J5.14, U1.AK4 (TRACEDATA[0]/P0.11)
/P0.12: J5.13, U1.AK6 (TRACECLK/P0.12)
/P0.23: J5.9, R17.1, U1.AK20 (P0.23)
/P0.24: J5.8, R18.1, U1.AL27 (P0.24)
/P0.25: J5.7, R19.1, U1.AK28 (AIN4/P0.25)
/P0.26: J5.6, U1.AL29 (AIN5/P0.26)
/P0.27: J5.5, U1.AK30 (AIN6/P0.27)
/P0.28: J5.4, U1.AE31 (AIN7/P0.28)
/P0.29: J5.3, U1.U31 (0.29)
/P0.30: J5.2, U1.B24 (P0.30)
/P0.31: J5.1, U1.B22 (P0.31)
/P1.0: J4.3, U1.M2 (P1.00)
/P1.1: J4.4, U1.P2 (P1.01)
/P1.2: J4.5, U1.AE1 (I2C/P1.02)
/P1.3: J4.6, U1.AF2 (I2C/P1.03)
/P1.4: J4.7, U1.AL19 (P1.04)
/P1.5: J4.8, U1.AK22 (P1.05)
/P1.6: J4.9, U1.AL21 (P1.06)
/P1.7: J4.10, U1.AK24 (P1.07)
/P1.9: J4.14, U1.AK26 (P1.09)
/P1.10: J4.15, U1.R31 (P1.10)
/P1.11: J4.16, U1.B20 (P1.11)
/P1.12: J4.17, U1.B18 (P1.12)
/P1.13: J4.18, U1.A17 (P1.13)
/P1.14: J4.19, U1.B16 (P1.14)
/P1.15: J4.20, U1.B14 (P1.15)
/QSPI_0: R8.2, U1.AL5 (QSPI[0]/P0.13), U3.5 (DI(IO0))
/QSPI_1: U1.AK8 (QSPI[1]/P0.14), U3.2 (DO(IO1))
/QSPI_2: U1.AK10 (QSPI[2]/P0.15), U3.3 (IO2)
/QSPI_3: U1.AL9 (QSPI[3]/P0.16), U3.7 (IO3)
/QSPI_CLK: U1.AK12 (QSPI_CLK/P0.17), U3.6 (CLK)
/QSPI_CS: U1.AK14 (QSPI_CS/P0.18), U3.1 (~CS)
/R_LED: J5.12, U1.AK16 (P0.20)
GNDREF: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.1, C24.2, C25.2, C26.2, C27.2, C28.1, C29.1, D1.1 (KB), D1.2 (KG), D1.3 (KR), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.2, J4.12, J4.23, J5.22, R4.1, R5.1, SW1.2, SW2.2, U1.A25 (VSS), U1.B12 (VSS), U1.B26 (VSS), U1.G1 (VSS), U1.H2 (VSS), U1.J31 (VSS), U1.VSS (VSS_PAD), U2.2 (GND), U3.4 (GND), U4.1 (GND), Y1.2, Y1.4
unnamed: AE1.1, R11.1
unnamed: AE2.1, R10.1
unnamed: C1.1, L1.1, R10.2, R11.2
unnamed: C2.1, L1.2, U1.L31 (ANT)
unnamed: C3.1, U1.C31 (XC1), Y1.3
unnamed: C4.1, U1.B30 (XC2), Y1.1
unnamed: C14.1, R9.2, SW1.1
unnamed: C16.1, U1.B6 (DECUSB)
unnamed: C17.1, U1.A23 (DECN)
unnamed: C18.1, U1.A13 (DECA)
unnamed: C19.1, U1.N1 (XL1/P0.00), Y2.2
unnamed: C20.1, U1.R1 (XL2/P0.01), Y2.1
unnamed: C21.2, C23.2, J3.2, U1.W1 (NCF1/P0.02)
unnamed: C22.1, C24.1, J3.1, U1.AA1 (NFC2/P0.03)
unnamed: D1.4 (AR), R1.1
unnamed: D1.5 (AG), R2.1
unnamed: D1.6 (AB), R3.1
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), R8.1
unnamed: D5.2 (A), R17.2
unnamed: D6.2 (A), R18.2
unnamed: D7.2 (A), R19.2
unnamed: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J1.2, U1.W31 (SWDCLK)
unnamed: J1.3, U1.AA31 (SWDIO)
unnamed: J2.A5 (CC1), R4.2
unnamed: J2.A6 (D+), J2.B6 (D+), U2.3 (I/O2)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.1 (I/O1)
unnamed: J2.B5 (CC2), R5.2
unnamed: L2.2, U1.A21 (DCC)
unnamed: L3.2, U1.B10 (DCCD)
unnamed: R12.1, U1.A5 (VBUS)
unnamed: R13.2, SW2.1
unnamed: R14.2, U2.4 (I/O2)
unnamed: R7.2, R15.2, U2.6 (I/O1)
unnamed: U1.A27 (DECR), U1.G31 (DECRF)
VBUS: C25.1, F1.1, J4.22, R6.2, R12.2, U2.5 (VBUS), U4.3 (VI)
VDD: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C26.1, C27.1, J1.4, J4.1, J4.11, J5.23, R9.1, R13.1, R16.1, U1.A19 (VDD), U1.AC1 (VDD), U1.AG1 (VDD), U1.AJ31 (VDD), U1.AL3 (VDD), U1.AL7 (VDD), U1.AL11 (VDD), U1.AL17 (VDD), U1.AL23 (P1.08), U1.AL25 (VDD), U1.B8 (VDD), U1.B28 (VDD), U1.C1 (VDD), U1.E1 (VDDH), U1.E31 (VDD), U1.L1 (VDD), U1.N31 (VDD), U1.U1 (VDD), U3.8 (VCC), U4.2 (VO)

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
Board: 2 copper layers, 74 parts (0 on the bottom side), 85 nets, no tracks yet.

## Commit log

2021-05-31 init comment
2021-05-31 change schematic
2021-06-02 add footprint and rating for each component
2021-06-03 Refactoring. Start trace
2021-06-03 test remove usb. Add base design board without trace
2021-06-03 refactor
